# IAR project standard_robot.ewp, settings and files
configuration standard_robot (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\application; ..\bsp\boards; ..\Code; ..\components; ..\application\protocol; ..\components\support; ..\components\devices; ..\components\algorithm; ..\components\algorithm\AHRS; ..\bsp; ..\Middlewares\ST\ARM; ..\Middlewares\ST\ARM\DSP\Inc; ..\Middlewares\ST\ARM\DSP\Lib; ..\Middlewares\ST\ARM\DSP; ..\Middlewares\ST\ARM\DSP\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: standard_robot.hex
  ILINK.IlinkOutputFile: standard_robot.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: adc.c can.c crc.c dma.c freertos.c gpio.c i2c.c main.c rng.c rtc.c spi.c stm32f4xx_hal_msp.c stm32f4xx_it.c tim.c usart.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
  group Bsp_board
    ../bsp/boards/: bsp_adc.c bsp_adc.h bsp_buzzer.c bsp_buzzer.h bsp_can.c bsp_can.h bsp_crc32.c bsp_crc32.h bsp_delay.c bsp_delay.h bsp_flash.c bsp_flash.h bsp_fric.c bsp_fric.h bsp_i2c.c bsp_i2c.h bsp_imu_pwm.c bsp_imu_pwm.h bsp_laser.c bsp_laser.h bsp_led.c bsp_led.h bsp_rc.c bsp_rc.h bsp_rng.c bsp_rng.h bsp_servo_pwm.c bsp_servo_pwm.h bsp_spi.c bsp_spi.h bsp_usart.c bsp_usart.h
    ../bsp/: bsp_dwt.c bsp_dwt.h bsp_PWM.c bsp_PWM.h
  group Code
    ../application/: CAN_receive.c CAN_receive.h
    ../Code/: detect_task.c detect_task.h remote_control.c remote_control.h zn_chassis_motor.c zn_chassis_motor.h zn_gimbal_motor.c zn_gimbal_motor.h zn_headfile.h zn_interaction.c zn_interaction.h zn_lib.c zn_lib.h zn_motor.c zn_motor.h zn_pid.c zn_pid.h
  group Code/dispaly
    ../Code/: ANO_DT.c ANO_DT.h
    ../components/devices/: OLED.c OLED.h oledfont.h
  group Code/IMU
    ../components/devices/: BMI088driver.c BMI088driver.h BMI088Middleware.c BMI088Middleware.h BMI088reg.h ist8310driver.c ist8310driver.h ist8310driver_middleware.c ist8310driver_middleware.h
    ../application/: ins.c ins.h
    ../components/algorithm/: kalman_filter.c kalman_filter.h QuaternionEKF.c QuaternionEKF.h
    ../components/algorithm/AHRS/: MahonyAHRS.c MahonyAHRS.h
  group Code/refree
    ../components/support/: CRC8_CRC16.c CRC8_CRC16.h fifo.c fifo.h linux_list.h macro_mutex.h mem_mang.h mem_mang4.c
    ../Code/: referee.c referee.h
  group Code/task
    ../Code/: INS_task.c INS_task.h referee_usart_task.c referee_usart_task.h voltage_task.c voltage_task.h zn_chassis_task.c zn_chassis_task.h zn_display_task.c zn_display_task.h zn_gimbal_task.c zn_gimbal_task.h zn_judge.c zn_judge.h zn_shoot_task.c zn_shoot_task.h zn_SlideBlock_task.c zn_SlideBlock_task.h
    ../application/: led_flow_task.c led_flow_task.h
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_adc.c stm32f4xx_ll_usb.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
